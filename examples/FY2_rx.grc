options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 660e3
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '7'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/user/Desktop/12-59-11_1687496263Hz.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '8.7e-3'
    gain_omega: 8.7e-3**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.000005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.002'
  states: {}
- name: fengyun2_data_saver_0
  id: fengyun2_data_saver
  parameters:
    log_state: 'True'
    path: /home/user/
  states: {state: disabled}
- name: fengyun2_decoder_0
  id: fengyun2_decoder
  parameters:
    path: '''/home/user/Desktop/'''
  states: {}
- name: fengyun2_diff_decoder_0
  id: fengyun2_diff_decoder
  parameters: {}
  states: {}
- name: fengyun2_sync_derand_0
  id: fengyun2_sync_derand
  parameters:
    threshold: threshold
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '512'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '1'
    ncols: '44356'
    nrows: '2940'
    samp_rate: '44356'
    type: float
    x_end_value: '0'
    zmax: '255'
    zmin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.50'
    decim: '1'
    gain: '1'
    ntaps: '31'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_float_to_complex_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', blocks_throttle2_0, '0']
- [digital_binary_slicer_fb_0, '0', fengyun2_diff_decoder_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [fengyun2_diff_decoder_0, '0', fengyun2_sync_derand_0, '0']
- [fengyun2_sync_derand_0, '0', blocks_uchar_to_float_0, '0']
- [fengyun2_sync_derand_0, '0', fengyun2_decoder_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
